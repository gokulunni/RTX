# Keil uVision project SVC.uvprojx, settings and files
target CS SIM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SVC
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG_0 SIM_TARGET DEBUG_PRIO_Q
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Documentation
    ./: Abstract.txt
  group Kernel IRQ code
    ./src/: uart_irq.c
  group Kernel sys call code
    ./src/: HAL.c k_mem.c k_msg.c k_rtx_init.c k_task.c circular_buffer.c linked_list.c timer.c k_time.c wall_clock_task.c helpers.c timeval.c
  group Kernel Tasks
    ./src/: lcd_task.c priv_tasks.c
  group System code
    ./src/: main_svc.c printf.c uart_polling.c
  group User Tasks
    ./src/: kcd_task.c null_task.c usr_tasks.c
target CS RAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: as above
  output: SVC
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: RAM_TARGET
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
